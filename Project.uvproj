# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c I2C.c I2C.h Delay.c Delay.h LCD1602.c LCD1602.h Key.c Key.h Timer0.c Timer0.h IR.c IR.h XPT2046.c XPT2046.h Int0.c Int0.h Timer1.c Timer1.h AT2402.c AT2402.h DS18B20.c DS18B20.h OneWire.c OneWire.h Buzzer.c Buzzer.h Temp_Warn.c Temp_Warn.h Timer2.c Timer2.h MOTOR_Monitor.c MOTOR_Monitor.h Menu.c Menu.h Lux_Get.c Lux_Get.h
